# Keil uVision project STM32_Quadcopter.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_Quadcopter
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c button.c button.h hal_timer_pwm.c hal_timer_pwm.h i2c_mpu_debug.c i2c_mpu_debug.h xx_mpu_data_fusion.c xx_mpu_data_fusion.h pid_control.c pid_control.h telemetry.h telemetry.c drn_button.c drn_button.h drn_timer_pwm.c drn_timer_pwm.h main_board_choose.c main_board_choose.h
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.0
